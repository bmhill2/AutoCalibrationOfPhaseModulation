options:
  parameters:
    author: sal
    generate_options: qt_gui
    id: niwc_pac_paper
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq1
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: freq2
  id: variable
  parameters:
    value: 5e3
  states: {}
- name: num_of_inputs
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: freq2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: predistort_async_signal_mux_0
  id: predistort_async_signal_mux
  parameters:
    num_inputs: num_of_inputs
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_static: 'False'
    key: stream
    label: Labels do not matter
    type: int
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_noise_source_x_0, '0', predistort_async_signal_mux_0, '2']
- [analog_sig_source_x_0, '0', predistort_async_signal_mux_0, '0']
- [analog_sig_source_x_0_0, '0', predistort_async_signal_mux_0, '1']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [predistort_async_signal_mux_0, '0', blocks_throttle_0, '0']
- [qtgui_edit_box_msg_0, msg, predistort_async_signal_mux_0, ctrl_in]

metadata:
  file_format: 1
