options:
  parameters:
    author: sal
    generate_options: qt_gui
    id: niwc_pac_paper_delayIQ
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: const
  id: variable_constellation
  parameters:
    const_points: '[0.707+0.707j, -0.707+0.707j, -0.707-0.707j, 0.707-0.707j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: variable_rrc_filter_taps_0
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.35'
    gain: '1.0'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/4
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: sps
    taps: variable_rrc_filter_taps_0
    type: ccc
  states: {}
- name: predistort_iq_delay_by_msg_0
  id: predistort_iq_delay_by_msg
  parameters:
    max_delay: '1024'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_edit_box_msg_0_0_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_static: 'False'
    key: value
    label: IQ Delay Set
    type: int_vec
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', predistort_iq_delay_by_msg_0, '0']
- [fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [predistort_iq_delay_by_msg_0, '0', fir_filter_xxx_0, '0']
- [qtgui_edit_box_msg_0_0_0_0_0, msg, predistort_iq_delay_by_msg_0, ctrl_in]

metadata:
  file_format: 1
