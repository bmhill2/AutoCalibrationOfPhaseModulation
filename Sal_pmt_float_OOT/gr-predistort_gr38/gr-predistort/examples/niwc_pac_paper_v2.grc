options:
  parameters:
    author: sal
    generate_options: qt_gui
    id: niwc_pac_paper
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: 1+2j
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: predistort_add_by_msg_0
  id: predistort_add_by_msg
  parameters: {}
  states: {}
- name: predistort_add_complex_by_msg_0
  id: predistort_add_complex_by_msg
  parameters: {}
  states: {}
- name: predistort_mult_by_msg_0
  id: predistort_mult_by_msg
  parameters: {}
  states: {}
- name: predistort_mult_complex_by_msg_0
  id: predistort_mult_complex_by_msg
  parameters: {}
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 0,0,1,4
    is_static: 'False'
    key: value
    label: Complex Add test
    type: flt_vec
    value: '.123'
  states: {}
- name: qtgui_edit_box_msg_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 2,0,1,4
    is_static: 'False'
    key: value
    label: Float Add test
    type: float
    value: '.1111'
  states: {}
- name: qtgui_edit_box_msg_0_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 4,0,1,4
    is_static: 'False'
    key: value
    label: Float Mult test
    type: float
    value: '.2222'
  states: {}
- name: qtgui_edit_box_msg_0_0_0_0_0
  id: qtgui_edit_box_msg
  parameters:
    gui_hint: 6,0,1,4
    is_static: 'False'
    key: value
    label: Complex Mult test
    type: flt_vec
    value: '-.456'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,2
    name: '"Complex (real) Add Results"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,2,1,2
    name: '"Complex (imag) Add Results"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 7,2,1,2
    name: '"Complex (imag) Mult Results"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 3,0,1,4
    name: '"Float Add Results"'
    type: float
  states: {}
- name: qtgui_number_sink_0_1_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 5,0,1,4
    name: '"Float Mult Results"'
    type: float
  states: {}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 7,0,1,2
    name: '"Complex (real) Mult Results"'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', predistort_add_complex_by_msg_0, '0']
- [analog_const_source_x_0_0, '0', predistort_add_by_msg_0, '0']
- [analog_const_source_x_0_0, '0', predistort_mult_by_msg_0, '0']
- [analog_const_source_x_0_1, '0', predistort_mult_complex_by_msg_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_number_sink_0_0, '0']
- [blocks_complex_to_float_0_0, '0', qtgui_number_sink_0_2, '0']
- [blocks_complex_to_float_0_0, '1', qtgui_number_sink_0_0_0, '0']
- [predistort_add_by_msg_0, '0', qtgui_number_sink_0_1, '0']
- [predistort_add_complex_by_msg_0, '0', blocks_complex_to_float_0, '0']
- [predistort_mult_by_msg_0, '0', qtgui_number_sink_0_1_1, '0']
- [predistort_mult_complex_by_msg_0, '0', blocks_complex_to_float_0_0, '0']
- [qtgui_edit_box_msg_0_0, msg, predistort_add_complex_by_msg_0, ctrl_in]
- [qtgui_edit_box_msg_0_0_0, msg, predistort_add_by_msg_0, ctrl_in]
- [qtgui_edit_box_msg_0_0_0_0, msg, predistort_mult_by_msg_0, ctrl_in]
- [qtgui_edit_box_msg_0_0_0_0_0, msg, predistort_mult_complex_by_msg_0, ctrl_in]

metadata:
  file_format: 1
